# Keil uVision project Measure.uvproj, settings and files
target Simulator: Binary Mode (MCS-251)
  device: T8xC251A1 Atmel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF5FFF)
  output: Measure
  group Source Group 1
    ./: MEASURE.C MCOMMAND.C GETLINE.C
    ../MCBx51/: MCB251C2.LIB
  group Documentation
    ./: ABSTRACT.TXT
target Simulator: Source Mode (MCS-251)
  device: T8xC251A1 Atmel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF5FFF)
  output: Measure +hex
  asm misc: REGISTERBANK (0)
target MCBx51: TSC251A1 Source Mode (MCS-251)
  device: T8xC251A1 Atmel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF5FFF)
  output: Measure +hex
  asm misc: MODSRC
target MCBx51: TSC251G1D/G2D (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: Measure +hex
