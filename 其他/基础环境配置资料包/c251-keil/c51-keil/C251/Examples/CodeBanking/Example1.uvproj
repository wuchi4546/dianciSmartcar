# Keil uVision project Example1.uvproj, settings and files
target Target 1 (MCS-251)
  device: T8xC251G2D Atmel
  cpu: IRAM(0 - 0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF7FFF)
  output: Example1 +hex
  group Source Files
    ./: C_ROOT.C C_BANK0.C C_BANK1.C C_BANK2.C L251BANK.A51
  group Documentation
    ./: ABSTRACT.TXT
