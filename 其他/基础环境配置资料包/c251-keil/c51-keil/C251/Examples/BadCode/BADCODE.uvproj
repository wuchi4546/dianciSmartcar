# Keil uVision project BADCODE.uvproj, settings and files
target Simulator: Source Mode (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: BADCODE +hex
  asm misc: REGISTERBANK (0)
  group Source Group 1
    ./: BADCODE.C
  group Documentation
    ./: ABSTRACT.TXT
