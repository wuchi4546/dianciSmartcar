# Keil uVision project DHRY.uvproj, settings and files
target Simulator: Binary Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: DHRY +hex
  group Source Group 1
    ./: DHRY.C TIME.C
    ../MCBx51/: MCB251C2.LIB
  group Documentation
    ./: ABSTRACT.TXT
target Simulator: Source Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: DHRY
target MCBx51: Source Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: DHRY +hex
