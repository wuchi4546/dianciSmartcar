# Keil uVision project BLINKY.uvproj, settings and files
target Simulator: Binary Mode (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: BLINKY +hex
  asm misc: FIXDRK REGISTERBANK (0)
  group Source Group 1
    ./: BLINKY.C
  group Documentation
    ./: ABSTRACT.TXT
target Simulator: Source Mode (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: BLINKY +hex
  asm misc: FIXDRK REGISTERBANK (0)
target MCB251: Binary Mode (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: BLINKY +hex
  asm misc: FIXDRK REGISTERBANK (0)
target MCB251: Source Mode (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(16000000) IROM(0xFF0000-0xFF3FFF)
  output: BLINKY +hex
  asm misc: FIXDRK REGISTERBANK (0)
