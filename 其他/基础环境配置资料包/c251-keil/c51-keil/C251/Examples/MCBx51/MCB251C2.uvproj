# Keil uVision project MCB251C2.uvproj, settings and files
target Source Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: MCB251C2 +hex (library)
  asm define: MCB251V2,C251V2
  asm misc: FIXDRK REGISTERBANK (0) MODSRC
  group Source Group 1
    ./: INIT.A51 VARS.A51 GETKEY.A51 PUTCHAR.A51 INSTAT.A51
  group Documentation
    ./: ABSTRACT.TXT
