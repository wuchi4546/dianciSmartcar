# Keil uVision project SIEVE.uvproj, settings and files
target Simulator: Binary Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: SIEVE +hex
  asm misc: FIXDRK REGISTERBANK (0)
  group Source Group 1
    ./: SIEVE.C
    ../MCBx51/: MCB251C2.LIB
  group Documentation
    ./: ABSTRACT.TXT
target Simulator: Source Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: SIEVE +hex
  asm misc: FIXDRK REGISTERBANK (0)
target MCBx51: Source Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: SIEVE +hex
  asm misc: FIXDRK REGISTERBANK (0)
