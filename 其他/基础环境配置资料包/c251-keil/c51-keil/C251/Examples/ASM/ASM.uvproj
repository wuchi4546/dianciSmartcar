# Keil uVision project ASM.uvproj, settings and files
target Simulator: Binary Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: ASM +hex
  asm misc: FIXDRK REGISTERBANK (0)
  group Source Group 1
    ./: ASAMPLE1.A51 ASAMPLE2.A51 ASAMPLE3.A51
  group Documentation
    ./: ABSTRACT.TXT
target Simulator: Source Mode (MCS-251)
  device: T8xC251G2D Atmel
  cpu: IRAM(0 - 0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF7FFF)
  output: ASM +hex
  asm misc: FIXDRK REGISTERBANK (0)
target MCBx51: Source Mode (MCS-251)
  device: T8xC251G1D Atmel
  cpu: IRAM(0-0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: ASM +hex
  asm misc: MODSRC
